File: Mimisbrunnr_PCB/gas_tank_temp_reg_PCB.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Improve style
Other:
- added sheet thermocouples (thermocouples.kicad_sch)
